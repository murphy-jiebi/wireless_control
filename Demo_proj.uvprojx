# Keil uVision project Demo_proj.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo_proj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --no-multibyte-chars
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\STM32F10x_StdPeriph_Driver\src;.\App\FATFS;.\App\SDCard;.\App\SPI;.\App\ADC;.\App\KEY;.\BSP\Inc;.\Task\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./User/: main.c stm32f10x_it.c delay.c tim.c bat.c LCD_USART3.c usart1.c LCD.c bsp_ws281x.c wired_port.c usart2.c
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ./Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_dma.c misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_usart.c stm32f10x_spi.c
  group FATFS
    ./App/FATFS/: diskio.c ff.c
  group SDCard
    ./App/SDCard/: sd_driver.c my_sd.c
  group SPI
    ./App/SPI/: spi.c
  group ADC
    ./App/ADC/: adc.c
  group KEY
    ./App/KEY/: key.c
  group BSP
    ./BSP/Src/: bsp_key.c bsp_gpio.c
  group APP
    ./Task/Src/: task_hc14.c task_ctrl.c
